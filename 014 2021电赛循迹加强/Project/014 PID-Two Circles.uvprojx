# Keil uVision project 014 PID-Two Circles.uvprojx, settings and files
target 014 PID-Two Circles (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 014 PID-Two Circles +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS;..\Fwlib\inc;..\User\Hardware;..\User\main;..\User\System
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Fwlib
    ../Fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MAIN
    ../User/main/: main.c stm32f10x_it.c
  group System
    C:/Users/Lenovo/Desktop/新建文件夹/STM32入门教程资料/程序源码/STM32Project-无注释版/1-3 Delay函数模块/: Delay.c Delay.h
    ../../004 Sysclock/User/System/: Sysclock.c Sysclock.h
    ../User/System/: EXTI.c EXTI.h TIMX.c TIMX.h UART.c UART.h ADC.c ADC.h PID.c PID.h Track.c Track.h
  group Hardware
    ../User/Hardware/: LED.c LED.h Key.c Key.h PWM.c PWM.h inv_mpu.c inv_mpu_dmp_motion_driver.c Encoder.c Encoder.h Motor.c Motor.h sensor.c sensor.h lightsensor.c lightsensor.h MPU6050.c MPU6050.h
    ../../007 状态机按键 1/User/Hardware/: English_Font.h OLED_Font.h SPI_OLED.c SPI_OLED.h
    ../../013 MPU6050/User/Hardware/: IIC24C64.c IIC24C64.h
